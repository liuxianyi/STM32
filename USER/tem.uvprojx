# Keil uVision project tem.uvprojx, settings and files
target goog (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tem +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F103ZE_LIB\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\keyBoard4_4;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\PID;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\USMART;..\HARDWARE\FDC2214;..\HARDWARE\TIMER;..\HARDWARE\TSL1401_CCD;..\HARDWARE\BlueTooth;..\HARDWARE\hcsr04;..\HARDWARE\shengbo\EXTI;..\HARDWARE\shengbo\TIMER;..\HARDWARE\shengbo\UltrasonicWave;..\HARDWARE\IIC_color
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LIB
    ../STM32F103ZE_LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group Description
    ../Description/: learning.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled1.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/keyBoard4_4/: keyBoard.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/FDC2214/: fdc2214.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../HARDWARE/TSL1401_CCD/: tsl1401_CCD.c
    ../HARDWARE/shengbo/EXTI/: exti_s.c
    ../HARDWARE/shengbo/TIMER/: timer_s.c
    ../HARDWARE/shengbo/UltrasonicWave/: UltrasonicWave.c
    ../HARDWARE/IIC_color/: IIC_color.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
